require mctp.inc

SUMMARY = "Management Component Control Protocol utilities"

FILES:${PN} = "${bindir}/mctp ${bindir}/mctp-client"
